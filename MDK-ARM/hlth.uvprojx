# Keil uVision project hlth.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32L053C8 STMicroelectronics
  pack: Keil.STM32L0xx_DFP.1.1.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x2000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: hlth
  c flags: Optim=4 wLevel=2
  c include: ..\CMSIS\Include;..\CMSIS\Device\ST\STM32L0xx\Include;..\Inc
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group USER
    ../Src/: main.c init.c Sendings.c AccelGyro.c
  group ::CMSIS
    C:/Keil_v5/ARM/PACK/ARM/CMSIS/4.2.0/CMSIS_RTX/LIB/ARM/: RTX_CM0.lib
    RTE/CMSIS/: RTX_Conf_CM.c
  group ::Device
    RTE/Device/STM32L053C8/: startup_stm32l053xx.s system_stm32l0xx.c
software components: CMSIS:CORE 3.40.0, CMSIS:RTOS:Keil RTX 4.75.0, Device:Startup 1.0.0
